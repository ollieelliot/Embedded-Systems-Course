# IAR project HW 2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Microchip\SAM3X\SAM3X-EK\sam3x8-sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: at91sam3x8.h button.c button.h core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s delay.c delay.h display.c display.h exceptions.c exceptions.h initpins.c initpins.h keypad.c keypad.h led.c led.h main.c my_library.c my_library.h photosensor.c photosensor.h servo.c servo.h startup_sam3x.c system_sam3x.c system_sam3x.h systick_setup.c systick_setup.h temperature.c temperature.h time.c time.h
